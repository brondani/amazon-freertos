# Keil uVision project aws-demos.uvprojx, settings and files
target CORE_MQTT_MUTUAL_AUTH_DEMO (6160000::V6.16::ARMCLANG)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: aws-demos
  group Source Group 1
    ./config_files/: aws_demo_config.h
    ../../../vendors/st/boards/stm32l475_discovery/aws_demos/application_code/st_code/: startup_stm32l475xx.s cmsis_os.c entropy_hardware_poll.c es_wifi_io.c flash_l4.c stm32l4xx_hal_timebase_TIM.c syscalls.c vl53l0x_platform.c vl53l0x_proximity.c
    ../../demo_runner/: aws_demo.c iot_demo_freertos.c iot_demo_runner.c
    ../../network_manager/: aws_iot_network_manager.c
    ../../coreMQTT/: mqtt_demo_mutual_auth.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L475VGTx/STCubeGenerated/Src/: main.c stm32l4xx_it.c
    ./RTE/Device/STM32L475VGTx/STCubeGenerated/Inc/: stm32l4xx_it.h
software components: RTOS:Config 10.3.1, RTOS:Core 10.3.1, RTOS:Coroutines 10.3.1, RTOS:Event Groups 10.3.1, RTOS:Heap 10.3.1, RTOS:Timers 10.3.1, CMSIS:CORE 5.5.0, Security:mbed TLS 2.24.0, AWS IoT:Features:Backoff Algorithm 1.0.1, AWS IoT:Features:CommonIO 1.0.0, AWS IoT:Features:Crypto 1.0.0, AWS IoT:Features:Key Provisioning 1.0.0, AWS IoT:Features:Logging 1.0.0, AWS IoT:Features:PKCS11 Helpers 1.0.0, AWS IoT:Features:PKCS11 Utils 1.0.0, AWS IoT:Features:Secure Sockets 1.0.0, AWS IoT:Features:Wifi 1.0.0, AWS IoT:Features:coreHTTP 2.0.1, AWS IoT:Features:coreMQTT 1.1.1, AWS IoT:Features:mbedTLS Utils 1.0.0, stm32l475_discovery:bsp_extensions 1.0.0, stm32l475_discovery:common_io 1.0.0, stm32l475_discovery:secure_sockets 1.0.0, stm32l475_discovery:wifi 1.0.0, Board Support:Drivers:Accelerometer 1.1.6, Board Support:Drivers:Basic I/O 1.1.6, Board Support:Drivers:Gyroscope 1.1.6, Board Support:Drivers:Humidity Sensor 1.1.6, Board Support:Drivers:Magnetometer 1.1.6, Board Support:Drivers:Pressure Sensor 1.1.6, Board Support:Drivers:QSPI 1.1.6, Board Support:Drivers:Temperature Sensor 1.1.6, Device:STM32Cube HAL:Common 1.12.0, Device:STM32Cube HAL:Cortex 1.12.0, Device:STM32Cube HAL:DMA 1.12.0, Device:STM32Cube HAL:Flash 1.12.0, Device:STM32Cube HAL:GPIO 1.12.0, Device:STM32Cube HAL:I2C 1.12.0, Device:STM32Cube HAL:PWR 1.12.0, Device:STM32Cube HAL:QSPI 1.12.0, Device:STM32Cube HAL:RCC 1.12.0, Device:STM32Cube HAL:RNG 1.12.0, Device:STM32Cube HAL:RTC 1.12.0, Device:STM32Cube HAL:SPI 1.12.0, Device:STM32Cube HAL:TIM 1.12.0, Device:STM32Cube HAL:UART 1.12.0, Device:Startup 1.3.1
